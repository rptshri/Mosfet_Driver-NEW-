File: MosfetDriverOn2104/POwer & Connectors.sch (KiCad schematic (older format))
At the start: 25 parts

Commit message: started routing
Parts:
- gave numbers to parts that had none: 25
